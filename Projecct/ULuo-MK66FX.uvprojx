# Keil uVision project ULuo-MK66FX.uvprojx, settings and files
target ULuo_MK66FX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x100000) IROM2(0x10000000,0x40000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ULuo-K66 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Libraries\startup\CoreSupport;..\Libraries\startup\DeviceSupport;..\Libraries\app;..\Libraries\drives\inc;..\Libraries\FatFs;..\Libraries\seekfree;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x40000
  group startup
    ../Libraries/startup/DeviceSupport/: startup_MK66F18.s system_MK66.c
  group library
    ../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group seekfree
    ../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_28LCD.c SEEKFREE_7725.c SEEKFREE_FUN.c SEEKFREE_IIC.c SEEKFREE_L3G4200D.c SEEKFREE_MMA8451.c SEEKFREE_MPU6050.c SEEKFREE_MT9V032.c SEEKFREE_NRF24L01.c SEEKFREE_OLED.c SEEKFREE_TSL1401.c
  group app
    ../Libraries/app/: PID.c
  group user
    ../User/: isr.c main.c
